SRC_URI += "file://user_2019-02-27-12-57-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

